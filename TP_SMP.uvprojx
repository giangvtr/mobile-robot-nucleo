# Keil uVision project TP_SMP.uvprojx, settings and files
target STM32F446 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TP_SMP +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./: main.c SysClock.c gpio.c SysTick.c
  group Inc
    ./: main.h SysClock.h gpio.h PinNames.h stm32f4xx_gpio_AF.h SysTick.h
  group StartUp
    ./: startup_stm32f446xx.s
software components: CMSIS:CORE 5.0.1
